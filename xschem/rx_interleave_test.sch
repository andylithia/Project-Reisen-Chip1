v {xschem version=3.0.0 file_version=1.2 
}
G {}
K {}
V {}
S {}
E {}
N -680 0 -680 30 {
lab=GND}
N -190 -100 -190 -90 {
lab=#net1}
N -130 -200 -130 -160 {
lab=Vref}
N 40 -200 120 -200 {
lab=Vref}
N -190 -30 -190 20 {
lab=GND}
N -80 -200 40 -200 {
lab=Vref}
N -680 30 -680 60 {
lab=GND}
N -480 330 -480 360 {
lab=GND}
N -420 330 -420 360 {
lab=GND}
N -360 330 -360 360 {
lab=GND}
N -300 330 -300 360 {
lab=GND}
N -240 330 -240 360 {
lab=GND}
N -180 330 -180 360 {
lab=GND}
N -120 330 -120 360 {
lab=GND}
N -60 330 -60 360 {
lab=GND}
N 510 -90 530 -90 {
lab=E0}
N 280 30 280 50 {
lab=GND}
N 280 -150 280 -130 {
lab=VDD}
N 280 50 280 60 {
lab=GND}
N -130 -200 -80 -200 {
lab=Vref}
N 350 -90 370 -90 {
lab=E0_pre}
N 350 -50 370 -50 {
lab=#net2}
N 280 -150 440 -150 {
lab=VDD}
N 440 -150 440 -130 {
lab=VDD}
N 440 0 440 40 {
lab=GND}
N 280 40 440 40 {
lab=GND}
N 510 170 530 170 {
lab=DM0}
N 280 290 280 310 {
lab=GND}
N 280 110 280 130 {
lab=VDD}
N 280 310 280 320 {
lab=GND}
N 350 170 370 170 {
lab=DM0_pre}
N 350 210 370 210 {
lab=#net3}
N 280 110 440 110 {
lab=VDD}
N 440 110 440 130 {
lab=VDD}
N 440 260 440 300 {
lab=GND}
N 280 300 440 300 {
lab=GND}
N 510 430 530 430 {
lab=E1}
N 280 550 280 570 {
lab=GND}
N 280 370 280 390 {
lab=VDD}
N 280 570 280 580 {
lab=GND}
N 350 430 370 430 {
lab=#net4}
N 350 470 370 470 {
lab=#net5}
N 280 370 440 370 {
lab=VDD}
N 440 370 440 390 {
lab=VDD}
N 440 520 440 560 {
lab=GND}
N 280 560 440 560 {
lab=GND}
N 510 690 530 690 {
lab=DM1}
N 280 810 280 830 {
lab=GND}
N 280 630 280 650 {
lab=VDD}
N 280 830 280 840 {
lab=GND}
N 350 690 370 690 {
lab=#net6}
N 350 730 370 730 {
lab=#net7}
N 280 630 440 630 {
lab=VDD}
N 440 630 440 650 {
lab=VDD}
N 440 780 440 820 {
lab=GND}
N 280 820 440 820 {
lab=GND}
N 510 -50 530 -50 {
lab=#net8}
N 1010 -90 1030 -90 {
lab=E2}
N 780 30 780 50 {
lab=GND}
N 780 -150 780 -130 {
lab=VDD}
N 780 50 780 60 {
lab=GND}
N 850 -90 870 -90 {
lab=#net9}
N 850 -50 870 -50 {
lab=#net10}
N 780 -150 940 -150 {
lab=VDD}
N 940 -150 940 -130 {
lab=VDD}
N 940 0 940 40 {
lab=GND}
N 780 40 940 40 {
lab=GND}
N 1010 170 1030 170 {
lab=DM2}
N 780 290 780 310 {
lab=GND}
N 780 110 780 130 {
lab=VDD}
N 780 310 780 320 {
lab=GND}
N 850 170 870 170 {
lab=#net11}
N 850 210 870 210 {
lab=#net12}
N 780 110 940 110 {
lab=VDD}
N 940 110 940 130 {
lab=VDD}
N 940 260 940 300 {
lab=GND}
N 780 300 940 300 {
lab=GND}
N 1010 430 1030 430 {
lab=E3}
N 780 550 780 570 {
lab=GND}
N 780 370 780 390 {
lab=VDD}
N 780 570 780 580 {
lab=GND}
N 850 430 870 430 {
lab=#net13}
N 850 470 870 470 {
lab=#net14}
N 780 370 940 370 {
lab=VDD}
N 940 370 940 390 {
lab=VDD}
N 940 520 940 560 {
lab=GND}
N 780 560 940 560 {
lab=GND}
N 1010 690 1030 690 {
lab=DM3}
N 780 810 780 830 {
lab=GND}
N 780 630 780 650 {
lab=VDD}
N 780 830 780 840 {
lab=GND}
N 850 690 870 690 {
lab=#net15}
N 850 730 870 730 {
lab=#net16}
N 780 630 940 630 {
lab=VDD}
N 940 630 940 650 {
lab=VDD}
N 940 780 940 820 {
lab=GND}
N 780 820 940 820 {
lab=GND}
N 1010 -50 1030 -50 {
lab=#net17}
N 640 -90 710 -90 {
lab=VIP}
N 640 -90 640 170 {
lab=VIP}
N 640 170 710 170 {
lab=VIP}
N 640 430 710 430 {
lab=VIP}
N 640 690 710 690 {
lab=VIP}
N 640 170 640 690 {
lab=VIP}
N 140 -90 210 -90 {
lab=VIP}
N 140 -90 140 170 {
lab=VIP}
N 140 170 210 170 {
lab=VIP}
N 140 430 210 430 {
lab=VIP}
N 140 690 210 690 {
lab=VIP}
N 140 170 140 690 {
lab=VIP}
N 140 -220 140 -90 {
lab=VIP}
N 140 -220 640 -220 {
lab=VIP}
N 640 -220 640 -90 {
lab=VIP}
N 120 -200 620 -200 {
lab=Vref}
N 620 -50 710 -50 {
lab=Vref}
N 620 210 710 210 {
lab=Vref}
N 620 470 710 470 {
lab=Vref}
N 620 730 710 730 {
lab=Vref}
N 620 -200 620 730 {
lab=Vref}
N 120 -50 210 -50 {
lab=Vref}
N 120 210 210 210 {
lab=Vref}
N 120 470 210 470 {
lab=Vref}
N 120 730 210 730 {
lab=Vref}
N 120 -200 120 730 {
lab=Vref}
N -680 -110 -680 -60 {
lab=VDD}
N -190 -220 -190 -160 {
lab=VIP}
N -190 -220 140 -220 {
lab=VIP}
N 350 -10 370 -10 {
lab=#net18}
N 510 210 530 210 {
lab=#net19}
N 350 250 370 250 {
lab=#net20}
N 1010 210 1030 210 {
lab=#net21}
N 850 250 870 250 {
lab=#net22}
N 850 -10 870 -10 {
lab=#net23}
N 1010 470 1030 470 {
lab=#net24}
N 850 510 870 510 {
lab=#net25}
N 510 470 530 470 {
lab=#net26}
N 350 510 370 510 {
lab=#net27}
N 510 730 530 730 {
lab=#net28}
N 350 770 370 770 {
lab=#net29}
N 1010 730 1030 730 {
lab=#net30}
N 850 770 870 770 {
lab=#net31}
N 1250 210 1320 210 {
lab=DM3}
N 1250 250 1320 250 {
lab=DM2}
N 1250 290 1320 290 {
lab=DM1}
N 1250 330 1320 330 {
lab=DM0}
N 1500 310 1520 310 {
lab=#net32}
N 1520 310 1520 330 {
lab=#net32}
N 1520 330 1560 330 {
lab=#net32}
N 1500 270 1520 270 {
lab=#net33}
N 1520 270 1520 290 {
lab=#net33}
N 1520 290 1560 290 {
lab=#net33}
N 1500 230 1520 230 {
lab=#net34}
N 1520 230 1520 250 {
lab=#net34}
N 1520 250 1560 250 {
lab=#net34}
N 1500 190 1520 190 {
lab=#net35}
N 1520 190 1520 210 {
lab=#net35}
N 1520 210 1560 210 {
lab=#net35}
N 1740 270 1760 270 {
lab=#net36}
N 1760 270 1760 290 {
lab=#net36}
N 1760 290 1800 290 {
lab=#net36}
N 1740 230 1760 230 {
lab=#net37}
N 1760 230 1760 250 {
lab=#net37}
N 1760 250 1800 250 {
lab=#net37}
N 1740 190 1760 190 {
lab=#net38}
N 1760 190 1760 210 {
lab=#net38}
N 1760 210 1800 210 {
lab=#net38}
N 1980 190 2000 190 {
lab=#net39}
N 2000 190 2000 210 {
lab=#net39}
N 2000 210 2040 210 {
lab=#net39}
N 1740 310 2340 310 {
lab=DMR0}
N 1980 270 2340 270 {
lab=DMR1}
N 1980 230 2340 230 {
lab=DMR2}
N 2220 190 2340 190 {
lab=DMR3}
N -130 -100 -130 -40 {
lab=#net40}
C {devices/vsource.sym} -680 -30 0 0 {name=V1 value=2}
C {devices/lab_wire.sym} 100 -220 0 0 {name=l2 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 100 -200 0 0 {name=l3 sig_type=std_logic lab=Vref}
C {devices/code_shown.sym} -550 -90 0 0 {name=s2 only_toplevel=false value=".tran 1000p 25n
.control
run
display
plot CKIN CKBUF
plot VIP Vref
plot VOP VON CKBUF VIP Vref
plot VONL VOPL
plot E0 E1 E2 E3
plot DM0 DM1 DM2 DM3
plot EQ0 EQ1 EQ2 EQ3
.endc
"}
C {devices/gnd.sym} -680 60 0 0 {name=l6 lab=GND}
C {devices/code.sym} -560 -230 0 0 {name=TT_MODELS1 only_toplevel=false
format="tcleval(@value )" value=".lib \\\\$::SKYWATER_MODELS\\\\/sky130.lib.spice tt
.include \\\\$::PDKPATH\\\\/libs.ref/sky130_fd_sc_hs/spice/sky130_fd_sc_hs.spice
"}
C {devices/res.sym} -190 -130 0 0 {name=R2
value=1
footprint=1206
device=resistor
m=1}
C {devices/vsource.sym} -130 -10 0 0 {name=V5 value=1.45}
C {devices/res.sym} -130 -130 0 0 {name=R4
value=50
footprint=1206
device=resistor
m=1}
C {devices/vsource.sym} -480 300 0 0 {name=Vck0 value="PULSE(0 1.8 0 0.05n 0.05n 0.4n 0.8n)"}
C {devices/gnd.sym} -480 360 0 0 {name=l11 lab=GND}
C {devices/vsource.sym} -420 300 0 0 {name=Vck1 value="PULSE(0 1.8 0.1n 0.05n 0.05n 0.4n 0.8n)"}
C {devices/vsource.sym} -360 300 0 0 {name=Vck2 value="PULSE(0 1.8 0.2n 0.05n 0.05n 0.4n 0.8n)"}
C {devices/vsource.sym} -300 300 0 0 {name=Vck3 value="PULSE(0 1.8 0.3n 0.05n 0.05n 0.4n 0.8n)"}
C {devices/gnd.sym} -420 360 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} -360 360 0 0 {name=l13 lab=GND}
C {devices/gnd.sym} -300 360 0 0 {name=l14 lab=GND}
C {devices/vsource.sym} -240 300 0 0 {name=Vck4 value="PULSE(0 1.8 0.4n 0.05n 0.05n 0.4n 0.8n)"}
C {devices/gnd.sym} -240 360 0 0 {name=l15 lab=GND}
C {devices/vsource.sym} -180 300 0 0 {name=Vck5 value="PULSE(0 1.8 0.5n 0.05n 0.05n 0.4n 0.8n)"}
C {devices/gnd.sym} -180 360 0 0 {name=l16 lab=GND}
C {devices/vsource.sym} -120 300 0 0 {name=Vck6 value="PULSE(0 1.8 0.6n 0.05n 0.05n 0.4n 0.8n)"}
C {devices/gnd.sym} -120 360 0 0 {name=l17 lab=GND}
C {devices/vsource.sym} -60 300 0 0 {name=Vck7 value="PULSE(0 1.8 0.7n 0.05n 0.05n 0.4n 0.8n)"}
C {devices/gnd.sym} -60 360 0 0 {name=l18 lab=GND}
C {sky130_stdcells/clkbuf_4.sym} -480 230 3 0 {name=x1 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/clkbuf_4.sym} -420 230 3 0 {name=x2 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/clkbuf_4.sym} -360 230 3 0 {name=x4 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/clkbuf_4.sym} -300 230 3 0 {name=x5 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/clkbuf_4.sym} -240 230 3 0 {name=x6 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/clkbuf_4.sym} -180 230 3 0 {name=x7 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/clkbuf_4.sym} -120 230 3 0 {name=x10 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/clkbuf_4.sym} -60 230 3 0 {name=x11 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {devices/lab_wire.sym} -480 190 0 0 {name=l19 sig_type=std_logic lab=CK0}
C {devices/lab_wire.sym} -420 190 0 0 {name=l20 sig_type=std_logic lab=CK1}
C {devices/lab_wire.sym} -360 190 0 0 {name=l21 sig_type=std_logic lab=CK2}
C {devices/lab_wire.sym} -300 190 0 0 {name=l22 sig_type=std_logic lab=CK3}
C {devices/lab_wire.sym} -240 190 0 0 {name=l23 sig_type=std_logic lab=CK4}
C {devices/lab_wire.sym} -180 190 0 0 {name=l24 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} -120 190 0 0 {name=l25 sig_type=std_logic lab=CK6}
C {devices/lab_wire.sym} -60 190 0 0 {name=l26 sig_type=std_logic lab=CK7}
C {devices/lab_wire.sym} 210 -90 0 0 {name=l27 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 530 -90 0 1 {name=l31 sig_type=std_logic lab=E0}
C {adc_strongarm_latch.sym} 440 -60 0 0 {name=x12}
C {adc_strongarm.sym} 280 -50 0 0 {name=x13}
C {devices/gnd.sym} 280 60 0 0 {name=l34 lab=GND}
C {devices/lab_wire.sym} 280 -150 0 0 {name=l35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 210 -10 0 0 {name=l36 sig_type=std_logic lab=CK0}
C {devices/lab_wire.sym} 530 170 0 1 {name=l32 sig_type=std_logic lab=DM0}
C {adc_strongarm_latch.sym} 440 200 0 0 {name=x14}
C {adc_strongarm.sym} 280 210 0 0 {name=x15}
C {devices/gnd.sym} 280 320 0 0 {name=l33 lab=GND}
C {devices/lab_wire.sym} 280 110 0 0 {name=l37 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 210 250 0 0 {name=l38 sig_type=std_logic lab=CK1}
C {devices/lab_wire.sym} 530 430 0 1 {name=l41 sig_type=std_logic lab=E1}
C {adc_strongarm_latch.sym} 440 460 0 0 {name=x16}
C {adc_strongarm.sym} 280 470 0 0 {name=x17}
C {devices/gnd.sym} 280 580 0 0 {name=l42 lab=GND}
C {devices/lab_wire.sym} 280 370 0 0 {name=l43 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 210 510 0 0 {name=l44 sig_type=std_logic lab=CK2}
C {devices/lab_wire.sym} 530 690 0 1 {name=l47 sig_type=std_logic lab=DM1}
C {adc_strongarm_latch.sym} 440 720 0 0 {name=x18}
C {adc_strongarm.sym} 280 730 0 0 {name=x19}
C {devices/gnd.sym} 280 840 0 0 {name=l48 lab=GND}
C {devices/lab_wire.sym} 280 630 0 0 {name=l49 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 210 770 0 0 {name=l50 sig_type=std_logic lab=CK3}
C {devices/lab_wire.sym} 1030 -90 0 1 {name=l55 sig_type=std_logic lab=E2}
C {adc_strongarm_latch.sym} 940 -60 0 0 {name=x20}
C {adc_strongarm.sym} 780 -50 0 0 {name=x21}
C {devices/gnd.sym} 780 60 0 0 {name=l56 lab=GND}
C {devices/lab_wire.sym} 780 -150 0 0 {name=l57 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 710 -10 0 0 {name=l58 sig_type=std_logic lab=CK4}
C {devices/lab_wire.sym} 1030 170 0 1 {name=l61 sig_type=std_logic lab=DM2}
C {adc_strongarm_latch.sym} 940 200 0 0 {name=x22}
C {adc_strongarm.sym} 780 210 0 0 {name=x23}
C {devices/gnd.sym} 780 320 0 0 {name=l62 lab=GND}
C {devices/lab_wire.sym} 780 110 0 0 {name=l63 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 710 250 0 0 {name=l64 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} 1030 430 0 1 {name=l67 sig_type=std_logic lab=E3}
C {adc_strongarm_latch.sym} 940 460 0 0 {name=x24}
C {adc_strongarm.sym} 780 470 0 0 {name=x25}
C {devices/gnd.sym} 780 580 0 0 {name=l68 lab=GND}
C {devices/lab_wire.sym} 780 370 0 0 {name=l69 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 710 510 0 0 {name=l70 sig_type=std_logic lab=CK6}
C {devices/lab_wire.sym} 1030 690 0 1 {name=l73 sig_type=std_logic lab=DM3}
C {adc_strongarm_latch.sym} 940 720 0 0 {name=x26}
C {adc_strongarm.sym} 780 730 0 0 {name=x27}
C {devices/gnd.sym} 780 840 0 0 {name=l74 lab=GND}
C {devices/lab_wire.sym} 780 630 0 0 {name=l75 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 710 770 0 0 {name=l76 sig_type=std_logic lab=CK7}
C {devices/vdd.sym} -680 -110 0 0 {name=l1 lab=VDD}
C {devices/gnd.sym} -190 20 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} -130 20 0 0 {name=l5 lab=GND}
C {devices/lab_wire.sym} 360 -90 0 1 {name=l45 sig_type=std_logic lab=E0_pre}
C {devices/lab_wire.sym} 360 170 0 1 {name=l46 sig_type=std_logic lab=DM0_pre}
C {devices/lab_wire.sym} 1250 330 0 1 {name=l51 sig_type=std_logic lab=DM0}
C {devices/lab_wire.sym} 1250 290 0 1 {name=l52 sig_type=std_logic lab=DM1}
C {devices/lab_wire.sym} 1250 250 0 1 {name=l53 sig_type=std_logic lab=DM2}
C {devices/lab_wire.sym} 1250 210 0 1 {name=l54 sig_type=std_logic lab=DM3}
C {sky130_stdcells/dfxtp_1.sym} 1410 200 0 0 {name=x29 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1410 240 0 0 {name=x30 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1410 280 0 0 {name=x31 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1410 320 0 0 {name=x32 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1650 320 0 0 {name=x33 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1650 280 0 0 {name=x34 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1650 240 0 0 {name=x35 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1650 200 0 0 {name=x36 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1890 280 0 0 {name=x37 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1890 240 0 0 {name=x38 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 1890 200 0 0 {name=x39 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/dfxtp_1.sym} 2130 200 0 0 {name=x40 VGND=gnd VNB=gnd VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hs__ }
C {devices/lab_wire.sym} 1320 190 0 0 {name=l59 sig_type=std_logic lab=CK3}
C {devices/lab_wire.sym} 1320 310 0 0 {name=l60 sig_type=std_logic lab=CK1}
C {devices/lab_wire.sym} 1560 230 0 0 {name=l65 sig_type=std_logic lab=CK1}
C {devices/lab_wire.sym} 1560 270 0 0 {name=l66 sig_type=std_logic lab=CK1}
C {devices/lab_wire.sym} 1800 190 0 0 {name=l71 sig_type=std_logic lab=CK1}
C {devices/lab_wire.sym} 1320 230 0 0 {name=l72 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} 1560 190 0 0 {name=l77 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} 2040 190 0 0 {name=l78 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} 1800 230 0 0 {name=l79 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} 1800 270 0 0 {name=l80 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} 1560 310 0 0 {name=l81 sig_type=std_logic lab=CK5}
C {devices/lab_wire.sym} 1320 270 0 0 {name=l82 sig_type=std_logic lab=CK7}
C {devices/lab_wire.sym} 2290 310 0 1 {name=l83 sig_type=std_logic lab=DMR0}
C {devices/lab_wire.sym} 2290 270 0 1 {name=l84 sig_type=std_logic lab=DMR1}
C {devices/lab_wire.sym} 2290 230 0 1 {name=l85 sig_type=std_logic lab=DMR2}
C {devices/lab_wire.sym} 2290 190 0 1 {name=l86 sig_type=std_logic lab=DMR3}
C {devices/vsource.sym} -20 40 0 0 {name=V2 value="PULSE(0.89 0.91 0 25n 0 1 2)"}
C {devices/gnd.sym} -20 70 0 0 {name=l7 lab=GND}
C {devices/vsource.sym} -190 -60 0 0 {name=Vck8 value="PULSE(1.2 1.7 0 0.05n 0.05n 0.395n 0.79n)"}
