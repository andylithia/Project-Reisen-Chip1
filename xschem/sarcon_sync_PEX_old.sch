** sch_path: xschem/sarcon_sync_PEX_old.sch
**.subckt sarcon_sync_PEX_old vhi vlo clk comp rst_n dq[0] dq[1] dq[2] dq[3] dq[4] dq[5] dq[6] dq[7]
*+ last_cycle valid
*.iopin vhi
*.iopin vlo
*.ipin clk
*.ipin comp
*.ipin rst_n
*.opin dq[0]
*.opin dq[1]
*.opin dq[2]
*.opin dq[3]
*.opin dq[4]
*.opin dq[5]
*.opin dq[6]
*.opin dq[7]
*.opin last_cycle
*.opin valid
**** begin user architecture code

* NGSPICE file created from sarcon_sync_flat.ext - technology: sky130A

.subckt sarcon_sync_flat clk comp dq[0] dq[1] dq[2] dq[3] dq[4] dq[5] dq[6] dq[7] last_cycle rst_n
+ valid vssd1 vccd1
X0 a_7768_3311# a_7369_3311# a_7642_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1 a_10769_2223# a_9779_2223# a_10643_2589# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X2 a_2673_2741# clknet_0_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.2305e+14p
+ ps=1.17422e+09u w=1e+06u l=150000u
X3 vccd1 a_6700_5175# _25_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X4 vccd1 a_10011_4551# sr\[4\] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X5 vccd1 a_12575_3855# a_12743_3829# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X6 vccd1 a_9187_5175# _06_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X7 vssd1 a_5234_2335# a_5192_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=7.69862e+13p pd=8.46e+08u as=0p
+ ps=0u w=420000u l=150000u
X8 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=1.05e+06u
X9 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=1.05e+06u
X10 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X11 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X12 vccd1 clknet_1_0__leaf_clk a_6743_4399# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X13 vssd1 a_7810_3423# a_7768_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X14 vccd1 a_12835_3579# a_12751_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X15 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X16 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X17 a_12410_3423# a_12242_3677# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X18 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X19 vccd1 a_2651_4087# sr\[3\] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X20 a_4847_3677# a_3983_3311# a_4590_3423# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X21 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X22 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X23 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X24 a_5013_3855# a_4675_4087# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X25 vssd1 a_2099_2375# net3 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X26 a_10133_2223# _02_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X27 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X28 a_12741_5461# sr\[4\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X29 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X30 vccd1 a_8235_3579# a_8151_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X31 a_13503_5309# net10 a_13140_5175# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X32 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X33 a_9920_5639# net7 a_10062_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X34 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X35 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X36 a_2939_5175# net2 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X37 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X38 vccd1 clknet_1_1__leaf_clk a_9779_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X39 a_7155_5487# net6 a_6792_5639# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X40 vssd1 a_10811_2491# a_10769_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X41 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X42 a_6934_5487# sr\[2\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X43 a_4793_2223# a_4627_2223# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X44 vccd1 _10_ a_3033_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X45 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X46 vccd1 a_16911_2986# _01_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X47 a_10062_5814# sr\[3\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X48 vccd1 clknet_1_0__leaf_clk a_2051_4399# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X49 a_7557_3311# _06_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X50 vccd1 clknet_1_1__leaf_clk a_11803_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X51 vccd1 a_6792_5639# _24_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X52 a_4590_3423# a_4422_3677# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X53 vssd1 a_10011_4551# sr\[4\] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X54 a_5055_4073# clknet_1_0__leaf_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X55 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X56 vccd1 sr\[1\] a_4043_4551# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X57 vccd1 a_11855_4373# _03_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X58 vccd1 a_11943_2375# sr_dly\[0\] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X59 a_12039_2197# a_12330_2497# a_12281_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X60 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X61 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X62 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X63 a_7197_4175# net11 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X64 a_12575_3855# a_11877_3861# a_12318_3829# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X65 vccd1 clknet_1_0__leaf_clk a_7203_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X66 vccd1 a_2686_2197# a_2615_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X67 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X68 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X69 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X70 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X71 vccd1 a_2019_5175# _30_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X72 net8 a_10811_3579# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X73 a_10643_3677# a_9945_3311# a_10386_3423# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X74 vccd1 a_12323_2197# a_12330_2497# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X75 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X76 vssd1 a_7847_7127# dq[3] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u
+ w=650000u l=150000u
X77 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X78 dq[5] a_14471_7127# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u
+ w=1e+06u l=150000u
X79 vccd1 a_10567_4087# _05_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X80 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X81 vccd1 a_7129_5241# a_7159_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X82 a_16463_3463# net2 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X83 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X84 a_8325_5241# net11 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X85 a_4149_3311# a_3983_3311# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X86 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X87 vccd1 a_3031_4073# a_3038_3977# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X88 a_16911_2986# _18_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X89 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X90 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X91 vccd1 a_10598_4373# a_10527_4399# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X92 a_17291_3463# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X93 a_9945_2223# a_9779_2223# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X94 vssd1 clknet_1_1__leaf_clk a_9779_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X95 vssd1 a_13140_5175# _20_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X96 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X97 dq[7] a_18059_7127# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=0p ps=0u
+ w=650000u l=150000u
D0 vssd1 rst_n sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
X98 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X99 vssd1 a_7896_5175# _26_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X100 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X101 vssd1 clknet_1_0__leaf_clk a_2051_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X102 vssd1 rst_n a_1867_2767# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X103 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X104 net11 a_3083_4667# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X105 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X106 a_10727_2589# a_9945_2223# a_10643_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X107 a_12659_3855# a_11877_3861# a_12575_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X108 vccd1 a_12318_2741# a_12245_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X109 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X110 a_11855_4373# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X111 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X112 a_12245_2767# a_11711_2773# a_12150_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X113 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X114 net5 a_3083_3579# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X115 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X116 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X117 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X118 net11 a_3083_4667# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X119 a_12150_3855# a_11711_3861# a_12065_3855# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X120 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X121 a_12771_5814# net1 a_12312_5639# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X122 a_14478_5487# sr\[5\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X123 a_8355_4982# net1 a_7896_5175# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X124 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X125 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X126 a_4422_3677# a_4149_3311# a_4337_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X127 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X128 a_14336_5639# net9 a_14478_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X129 vccd1 _15_ a_10945_4399# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X130 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X131 a_10218_3677# a_9779_3311# a_10133_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X132 a_6792_5639# net6 a_6934_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X133 a_8259_5309# net4 a_7896_5175# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X134 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X135 a_12276_4233# a_11877_3861# a_12150_3855# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X136 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X137 vssd1 _30_ a_1959_3855# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X138 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X139 a_11877_3861# a_11711_3861# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X140 vccd1 a_4036_7093# dq[1] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u
+ w=1e+06u l=150000u
X141 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X142 a_2405_3311# _08_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X143 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X144 a_2658_3423# a_2490_3677# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X145 a_10344_3311# a_9945_3311# a_10218_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X146 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X147 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X148 dq[1] a_4036_7093# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=0p ps=0u
+ w=650000u l=150000u
X149 a_6700_5175# net5 a_6842_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X150 vssd1 a_12575_3855# a_12743_3829# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X151 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X152 vccd1 a_17291_3463# _18_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X153 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X154 a_12073_4399# sr\[7\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X155 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X156 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X157 vccd1 a_4590_3423# a_4517_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X158 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X159 a_10349_5461# sr\[3\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X160 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X161 a_5617_2223# a_4627_2223# a_5491_2589# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X162 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X163 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X164 vccd1 a_12667_3677# a_12835_3579# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X165 vssd1 a_10386_3423# a_10344_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X166 a_6842_4982# sr\[1\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X167 net7 a_8235_3579# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X168 vssd1 a_5692_7093# dq[2] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u
+ w=650000u l=150000u
X169 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X170 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X171 vccd1 clk a_7838_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X172 vccd1 a_15807_3476# _16_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X173 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X174 sr\[1\] a_7775_4667# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X175 vssd1 a_12775_4373# _04_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X176 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X177 a_6792_5639# net1 a_6934_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X178 a_6553_3311# _17_ a_6335_3285# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X179 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X180 a_10901_5241# sr_dly\[0\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X181 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X182 vccd1 a_5262_4132# a_5191_4233# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X183 vccd1 sr\[6\] a_13078_4649# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X184 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X185 dq[0] a_1644_7093# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=0p ps=0u
+ w=650000u l=150000u
X186 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X187 vccd1 a_13569_5241# a_13599_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X188 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X189 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X190 a_2490_4765# a_2051_4399# a_2405_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X191 vssd1 a_16911_2986# _01_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X192 a_7607_4765# a_6909_4399# a_7350_4511# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X193 vccd1 a_4847_3677# a_5015_3579# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X194 a_7557_3311# _06_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X195 a_7347_2197# a_7638_2497# a_7589_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X196 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X197 a_10133_3311# _05_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X198 vssd1 net2 a_16981_4193# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X199 vssd1 a_2651_4087# sr\[3\] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X200 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X201 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X202 vssd1 a_5659_2491# a_5617_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X203 a_2616_4399# a_2217_4399# a_2490_4765# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X204 vccd1 a_5875_4373# _09_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X205 vssd1 a_4955_4373# _07_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X206 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X207 a_2437_2589# a_2099_2375# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X208 a_3111_5652# _28_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X209 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X210 net7 a_8235_3579# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X211 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X212 vccd1 a_7631_2197# a_7638_2497# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X213 vccd1 sr\[3\] a_5258_4649# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X214 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X215 a_2747_4087# a_3031_4073# a_2966_4221# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X216 _00_ _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X217 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X218 vssd1 a_2658_4511# a_2616_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X219 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X220 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X221 vssd1 _16_ a_8185_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X222 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X223 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X224 vssd1 a_12312_5639# _22_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X225 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X226 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X227 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X228 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X229 net2 a_1867_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X230 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X231 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X232 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X233 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X234 vccd1 a_5491_2589# a_5659_2491# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X235 a_2615_2223# a_2479_2197# a_2195_2197# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X236 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X237 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X238 vccd1 a_4675_4087# net4 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X239 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X240 dq[2] a_5692_7093# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u
+ w=1e+06u l=150000u
X241 vccd1 a_4043_4551# _28_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X242 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X243 vccd1 clknet_0_clk a_7930_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X244 vccd1 a_12530_2197# a_12459_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X245 a_7838_2197# a_7631_2197# a_8014_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X246 vccd1 a_2099_2375# net3 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X247 vssd1 a_10472_5175# _27_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X248 a_10379_5814# net1 a_9920_5639# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X249 a_2405_4399# _11_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X250 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X251 a_14411_4427# sr\[7\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X252 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X253 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X254 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X255 vccd1 sr\[4\] a_9490_4943# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X256 vssd1 a_2479_2197# a_2486_2497# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X257 vssd1 a_15807_3476# _16_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X258 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X259 a_2999_4765# a_2217_4399# a_2915_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X260 a_7182_4765# a_6743_4399# a_7097_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X261 vccd1 a_2658_3423# a_2585_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X262 vssd1 a_3083_3579# a_3041_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X263 a_6335_3285# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X264 a_7838_2767# clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X265 a_14765_5461# sr\[5\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X266 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X267 a_5875_4373# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X268 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X269 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X270 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X271 vccd1 net11 a_17507_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X272 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X273 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X274 a_7896_5175# net1 a_8038_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X275 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X276 vssd1 net2 a_14497_4427# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X277 a_7838_2197# a_7638_2497# a_7987_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X278 a_2585_3677# a_2051_3311# a_2490_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X279 vccd1 a_5871_5162# _14_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X280 a_5066_2589# a_4793_2223# a_4981_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X281 a_7308_4399# a_6909_4399# a_7182_4765# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X282 a_12701_3145# a_11711_2773# a_12575_2767# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X283 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X284 vssd1 a_5491_2589# a_5659_2491# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X285 vssd1 net11 a_17507_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X286 vssd1 a_6979_4087# _10_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X287 a_8185_2223# a_7631_2197# a_7838_2197# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X288 vssd1 a_10391_4373# a_10398_4673# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X289 a_8185_2223# a_7638_2497# a_7838_2197# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X290 vccd1 a_12741_5461# a_12771_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X291 vccd1 net2 a_3707_4951# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X292 vssd1 a_7350_4511# a_7308_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X293 vssd1 a_3031_4073# a_3038_3977# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X294 a_12667_3677# a_11969_3311# a_12410_3423# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X295 vssd1 a_14471_7127# dq[5] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u
+ w=650000u l=150000u
X296 a_11127_5639# sr\[4\] a_11301_5515# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X297 _19_ a_14411_4427# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X298 a_5438_3855# a_5191_4233# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X299 vssd1 a_3707_4951# _17_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X300 vccd1 a_3083_4667# a_2999_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X301 a_12073_4399# _17_ a_11855_4373# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X302 a_3111_5652# _28_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X303 vccd1 a_11127_5639# _31_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X304 a_8067_3677# a_7369_3311# a_7810_3423# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X305 a_2939_5175# sr\[2\] a_3113_5281# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X306 a_10349_4765# a_10011_4551# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X307 vccd1 a_5234_2335# a_5161_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X308 vccd1 a_5055_4073# a_5062_3977# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X309 vccd1 net2 a_16895_4193# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X310 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X311 vccd1 a_1867_2767# net2 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X312 vssd1 a_10055_7119# net1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X313 vccd1 a_2939_5175# _29_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X314 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X315 a_12065_3855# _03_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X316 a_10386_2335# a_10218_2589# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X317 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X318 a_6093_4399# sr\[1\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X319 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X320 a_10386_2335# a_10218_2589# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X321 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X322 _17_ a_3707_4951# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X323 a_5161_2589# a_4627_2223# a_5066_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X324 net8 a_10811_3579# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X325 a_6553_3311# sr\[2\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X326 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X327 a_10769_3311# a_9779_3311# a_10643_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X328 a_10062_5487# sr\[3\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X329 a_10472_5175# net1 a_10614_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X330 a_5609_4233# a_5062_3977# a_5262_4132# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X331 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X332 a_7097_4399# _12_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X333 a_7737_3677# a_7203_3311# a_7642_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X334 a_4847_3677# a_4149_3311# a_4590_3423# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X335 last_cycle a_17507_2223# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=0p
+ ps=0u w=650000u l=150000u
X336 vssd1 _23_ a_9405_5263# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X337 a_8325_5241# net11 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X338 vssd1 clknet_1_0__leaf_clk a_6743_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X339 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X340 a_5692_7093# net5 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X341 vccd1 sr\[5\] a_10870_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X342 a_10527_4399# a_10391_4373# a_10107_4373# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X343 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X344 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X345 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X346 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X347 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X348 dq[6] a_16863_7127# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p
+ ps=0u w=1e+06u l=150000u
X349 vccd1 a_10901_5241# a_10931_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X350 a_3238_4132# a_3031_4073# a_3414_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X351 vccd1 net8 a_14471_7127# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X352 a_10133_3311# _05_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X353 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X354 a_14795_5814# net1 a_14336_5639# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X355 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X356 a_12775_4373# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X357 a_3414_3855# a_3167_4233# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X358 vssd1 a_7251_2375# sr\[5\] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X359 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X360 vssd1 a_5871_5162# _14_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X361 vssd1 clknet_1_0__leaf_clk a_2051_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X362 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X363 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X364 a_12242_3677# a_11803_3311# a_12157_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X365 vssd1 a_10811_3579# a_10769_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X366 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X367 a_12150_2767# a_11877_2773# a_12065_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X368 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X369 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X370 vccd1 a_17507_2223# last_cycle vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p
+ ps=2.54e+06u w=1e+06u l=150000u
X371 a_12368_3311# a_11969_3311# a_12242_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X372 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X373 vccd1 a_18059_7127# dq[7] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p
+ ps=2.54e+06u w=1e+06u l=150000u
X374 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X375 vccd1 clknet_1_1__leaf_clk a_11711_2773# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X376 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X377 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X378 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X379 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X380 vccd1 _16_ a_8185_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X381 a_10011_4551# a_10107_4373# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X382 a_16463_3463# sr\[6\] a_16637_3339# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X383 a_7838_2767# clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X384 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X385 vssd1 clknet_0_clk a_2673_2741# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X386 a_3585_4233# a_3038_3977# a_3238_4132# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X387 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X388 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X389 a_2217_3311# a_2051_3311# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X390 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X391 vssd1 a_12410_3423# a_12368_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X392 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X393 a_6909_4399# a_6743_4399# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X394 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X395 a_3238_4132# a_3038_3977# a_3387_4221# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X396 a_4422_3677# a_3983_3311# a_4337_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X397 vccd1 a_7838_2197# a_7767_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X398 a_2651_4087# a_2747_4087# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X399 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X400 a_10218_2589# a_9945_2223# a_10133_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X401 vssd1 _22_ a_10785_4175# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X402 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X403 a_15531_4074# _19_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X404 vssd1 a_3238_4132# a_3167_4233# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X405 a_3585_4233# a_3031_4073# a_3238_4132# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X406 a_4548_3311# a_4149_3311# a_4422_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X407 a_2673_2741# clknet_0_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X408 vssd1 a_12741_5461# a_12675_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X409 a_2658_4511# a_2490_4765# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X410 vssd1 _21_ a_12993_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X411 a_13078_4649# _21_ a_12775_4373# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X412 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X413 vccd1 sr\[2\] a_2939_5175# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X414 a_9945_3311# a_9779_3311# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X415 vccd1 a_12263_7127# dq[4] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p
+ ps=2.54e+06u w=1e+06u l=150000u
X416 vssd1 clknet_1_1__leaf_clk a_9779_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X417 a_13282_5309# sr\[6\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X418 a_12157_3311# _04_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X419 vssd1 a_4590_3423# a_4548_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X420 a_4793_2223# a_4627_2223# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X421 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X422 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X423 a_11969_3311# a_11803_3311# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X424 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X425 vssd1 a_4675_4087# net4 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X426 vccd1 a_10386_2335# a_10313_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X427 vssd1 clknet_1_1__leaf_clk a_11803_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X428 a_10727_3677# a_9945_3311# a_10643_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X429 a_10011_4551# a_10107_4373# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X430 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X431 vccd1 a_12318_3829# a_12245_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X432 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X433 a_12459_2223# a_12323_2197# a_12039_2197# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X434 vccd1 a_5015_3579# a_4931_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X435 vccd1 a_16463_3463# _33_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X436 dq[4] a_12263_7127# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=0p ps=0u
+ w=650000u l=150000u
X437 a_7369_3311# a_7203_3311# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X438 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X439 a_2193_5281# net2 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X440 a_5191_4233# a_5055_4073# a_4771_4087# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X441 vssd1 clknet_1_0__leaf_clk a_7203_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X442 a_10313_2589# a_9779_2223# a_10218_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X443 a_12245_3855# a_11711_3861# a_12150_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X444 a_10349_5461# sr\[3\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X445 vssd1 _09_ a_5609_4233# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X446 sr\[7\] a_12743_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X447 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X448 vssd1 _24_ a_5173_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X449 a_4771_4087# a_5055_4073# a_4990_4221# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X450 vccd1 clk a_7838_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X451 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X452 a_5258_4649# _24_ a_4955_4373# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X453 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X454 dq[3] a_7847_7127# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X455 vssd1 a_12323_2197# a_12330_2497# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X456 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X457 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X458 a_7930_3855# clknet_0_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X459 a_4337_3311# _07_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X460 vssd1 a_14336_5639# _21_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X461 a_6093_4399# _17_ a_5875_4373# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X462 vccd1 net11 a_7282_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X463 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X464 a_7733_4399# a_6743_4399# a_7607_4765# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X465 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X466 a_3031_4073# clknet_1_0__leaf_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X467 vccd1 clknet_1_0__leaf_clk a_3983_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X468 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X469 vccd1 net11 a_17291_3463# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X470 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X471 a_2405_4399# _11_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X472 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X473 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X474 a_3167_4233# a_3038_3977# a_2747_4087# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X475 vccd1 _14_ a_3585_4233# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X476 a_5411_4221# a_5191_4233# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X477 a_9945_2223# a_9779_2223# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X478 vssd1 net10 a_18059_7127# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X479 a_16911_2388# _32_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X480 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X481 vssd1 a_9187_5175# _06_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X482 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X483 vccd1 a_5659_2491# a_5575_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X484 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X485 vssd1 a_9920_5639# _23_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X486 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X487 a_5234_2335# a_5066_2589# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X488 a_5234_2335# a_5066_2589# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X489 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X490 a_7930_3855# clknet_0_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X491 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X492 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X493 a_7810_3423# a_7642_3677# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X494 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X495 _12_ a_2235_5487# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X496 a_9490_4943# _23_ a_9187_5175# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X497 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X498 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X499 vssd1 a_17291_3463# _18_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X500 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X501 vssd1 a_7775_4667# a_7733_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X502 sr\[1\] a_7775_4667# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X503 vssd1 a_2686_2197# a_2615_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X504 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X505 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
R0 a_14419_2197# vccd1 sky130_fd_pr__res_generic_po w=480000u l=45000u
X506 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X507 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X508 vssd1 _17_ _00_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X509 vccd1 a_13140_5175# _20_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X510 vssd1 clknet_0_clk a_2673_2741# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X511 vccd1 a_7896_5175# _26_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X512 _32_ a_16895_4193# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X513 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X514 vssd1 a_10643_2589# a_10811_2491# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X515 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X516 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X517 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X518 a_2966_4221# a_2651_4087# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X519 vccd1 clknet_1_0__leaf_clk a_4627_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X520 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X521 a_2195_2197# a_2479_2197# a_2414_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X522 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X523 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X524 vccd1 a_14765_5461# a_14795_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X525 vssd1 a_5055_4073# a_5062_3977# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X526 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X527 vssd1 net7 a_12263_7127# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X528 a_6700_5175# net1 a_6842_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X529 vssd1 a_7129_5241# a_7063_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X530 a_4043_4551# net2 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X531 vssd1 a_10598_4373# a_10527_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X532 a_3041_3311# a_2051_3311# a_2915_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X533 vssd1 a_3083_4667# a_3041_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X534 a_8038_5309# net11 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X535 a_9187_5175# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X536 vssd1 _27_ a_7197_4175# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X537 vssd1 net2 a_3707_4951# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X538 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X539 vssd1 a_10349_5461# a_10283_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X540 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X541 vssd1 net6 a_7847_7127# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X542 vccd1 a_7847_7127# dq[3] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u
+ w=1e+06u l=150000u
X543 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X544 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X545 a_2490_3677# a_2217_3311# a_2405_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X546 a_4043_4551# sr\[1\] a_4217_4427# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X547 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X548 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X549 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X550 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X551 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X552 a_13569_5241# sr\[6\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X553 vssd1 a_7838_2197# a_7767_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X554 a_7097_4399# _12_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X555 a_12575_2767# a_11711_2773# a_12318_2741# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X556 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X557 a_14765_5461# sr\[5\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X558 a_12993_4399# _17_ a_12775_4373# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X559 a_2479_2197# clknet_1_0__leaf_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X560 net9 a_12835_3579# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X561 a_2019_5175# net2 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X562 a_7589_2589# a_7251_2375# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X563 vssd1 a_12318_2741# a_12276_3145# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X564 vssd1 a_16863_7127# dq[6] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u
+ w=650000u l=150000u
X565 vccd1 a_7607_4765# a_7775_4667# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X566 vssd1 a_10567_4087# _05_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X567 a_7221_5461# sr\[2\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X568 a_15531_4074# _19_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X569 dq[7] a_18059_7127# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X570 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X571 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X572 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X573 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X574 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X575 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X576 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X577 a_10870_3855# _22_ a_10567_4087# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X578 a_16637_3339# net2 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X579 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X580 vssd1 clknet_0_clk a_7930_3855# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X581 a_16911_2388# _32_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X582 vssd1 a_1644_7093# dq[0] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X583 vssd1 a_7607_4765# a_7775_4667# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X584 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X585 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X586 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X587 a_17465_3339# _17_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X588 a_12157_3311# _04_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X589 a_11127_5639# net2 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X590 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X591 a_10614_5309# sr_dly\[0\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X592 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X593 vccd1 a_12743_2741# a_12659_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X594 a_16981_4193# sr\[5\] a_16895_4193# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X595 net6 a_5015_3579# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X596 a_7767_2223# a_7631_2197# a_7347_2197# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X597 _12_ a_2235_5487# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X598 vccd1 a_8325_5241# a_8355_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X599 a_5262_4132# a_5055_4073# a_5438_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X600 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X601 a_10643_2589# a_9779_2223# a_10386_2335# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X602 a_12065_2767# _00_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X603 a_7642_3677# a_7369_3311# a_7557_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X604 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X605 a_2651_4087# a_2747_4087# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X606 vccd1 a_16911_2388# _15_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X607 vccd1 a_7251_2375# sr\[5\] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X608 vssd1 clknet_1_1__leaf_clk a_11711_2773# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X609 vccd1 a_2658_4511# a_2585_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X610 net9 a_12835_3579# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X611 vssd1 a_12835_3579# a_12793_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X612 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X613 vccd1 a_6335_3285# _08_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X614 a_2673_2741# clknet_0_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X615 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X616 a_11943_2375# a_12039_2197# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X617 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X618 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X619 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X620 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X621 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X622 a_10567_4087# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X623 a_7631_2197# clknet_1_1__leaf_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X624 vssd1 a_7631_2197# a_7638_2497# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X625 sr\[7\] a_12743_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X626 a_2585_4765# a_2051_4399# a_2490_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X627 vssd1 a_8235_3579# a_8193_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X628 a_4337_3311# _07_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X629 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X630 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X631 a_12701_4233# a_11711_3861# a_12575_3855# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X632 vccd1 a_10811_2491# a_10727_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X633 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X634 vccd1 a_7810_3423# a_7737_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X635 dq[1] a_4036_7093# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X636 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X637 net6 a_5015_3579# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X638 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X639 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X640 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X641 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X642 vccd1 a_5692_7093# dq[2] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X643 vssd1 a_13569_5241# a_13503_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X644 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X645 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X646 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X647 a_7691_4765# a_6909_4399# a_7607_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X648 vssd1 a_2915_3677# a_3083_3579# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X649 vssd1 a_14765_5461# a_14699_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X650 _13_ a_1959_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X651 a_5609_4233# a_5055_4073# a_5262_4132# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X652 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X653 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X654 a_10386_3423# a_10218_3677# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X655 a_10386_3423# a_10218_3677# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X656 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X657 a_10391_4373# clknet_1_1__leaf_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X658 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X659 a_2989_3855# a_2651_4087# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X660 dq[0] a_1644_7093# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u
+ w=1e+06u l=150000u
X661 vccd1 a_10055_7119# net1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X662 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X663 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X664 a_7251_5814# net1 a_6792_5639# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X665 vccd1 a_10472_5175# _27_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X666 vccd1 rst_n a_1867_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X667 vssd1 a_6792_5639# _24_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X668 a_13140_5175# net10 a_13282_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X669 clknet_0_clk a_7838_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X670 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X671 a_12675_5487# net8 a_12312_5639# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X672 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X673 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X674 a_12751_3677# a_11969_3311# a_12667_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X675 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X676 sr\[2\] a_5659_2491# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X677 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X678 a_13282_4982# sr\[6\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X679 a_2686_2197# a_2479_2197# a_2862_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X680 a_7277_4765# a_6743_4399# a_7182_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X681 a_12258_2223# a_11943_2375# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X682 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X683 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X684 a_3031_4073# clknet_1_0__leaf_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X685 a_8151_3677# a_7369_3311# a_8067_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X686 vssd1 a_16911_2388# _15_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X687 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X688 a_2835_2223# a_2615_2223# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X689 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X690 a_2862_2589# a_2615_2223# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X691 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X692 vssd1 a_8067_3677# a_8235_3579# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X693 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X694 a_2747_4087# a_3038_3977# a_2989_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X695 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X696 a_5692_7093# net5 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X697 vccd1 a_12775_4373# _04_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X698 vssd1 a_11855_4373# _03_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X699 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X700 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X701 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X702 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X703 a_7282_3855# _27_ a_6979_4087# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X704 a_16895_4193# sr\[5\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X705 a_2099_2375# a_2195_2197# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X706 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X707 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X708 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X709 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X710 vssd1 a_12530_2197# a_12459_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X711 a_4931_3677# a_4149_3311# a_4847_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X712 a_2686_2197# a_2486_2497# a_2835_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X713 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X714 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X715 vccd1 a_3707_4951# _17_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X716 vccd1 sr\[7\] a_12158_4649# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X717 a_12150_3855# a_11877_3861# a_12065_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X718 a_4036_7093# net4 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X719 vccd1 clknet_1_1__leaf_clk a_11711_3861# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X720 a_12281_2589# a_11943_2375# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X721 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X722 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X723 a_12337_3677# a_11803_3311# a_12242_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X724 a_2915_3677# a_2051_3311# a_2658_3423# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X725 vccd1 a_3111_5652# _11_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X726 a_10747_4399# a_10527_4399# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X727 vssd1 a_17507_2223# last_cycle vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X728 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X729 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X730 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X731 a_2217_4399# a_2051_4399# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X732 a_6909_4399# a_6743_4399# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X733 a_12039_2197# a_12323_2197# a_12258_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X734 vccd1 a_10349_5461# a_10379_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X735 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X736 a_7129_5241# sr\[1\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X737 vccd1 a_4955_4373# _07_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X738 vssd1 net9 a_16863_7127# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X739 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X740 a_10598_4373# a_10398_4673# a_10747_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X741 a_6979_4087# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X742 a_10218_3677# a_9945_3311# a_10133_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X743 a_2915_3677# a_2217_3311# a_2658_3423# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X744 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X745 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X746 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X747 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X748 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X749 a_1644_7093# net3 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X750 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X751 a_2658_3423# a_2490_3677# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X752 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X753 a_10945_4399# a_10391_4373# a_10598_4373# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X754 a_7251_2375# a_7347_2197# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X755 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X756 a_14497_4427# sr\[7\] a_14411_4427# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X757 vssd1 a_6700_5175# _25_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X758 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X759 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X760 vssd1 comp a_10055_7119# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X761 a_12323_2197# clknet_1_1__leaf_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X762 a_5491_2589# a_4627_2223# a_5234_2335# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X763 vssd1 a_12743_2741# a_12701_3145# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X764 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X765 vccd1 a_7838_2767# clknet_0_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X766 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X767 vccd1 a_10386_3423# a_10313_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X768 vccd1 a_14471_7127# dq[5] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X769 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X770 a_11877_2773# a_11711_2773# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X771 a_12312_5639# net8 a_12454_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X772 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X773 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X774 vccd1 a_10643_2589# a_10811_2491# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X775 dq[5] a_14471_7127# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X776 a_7159_4982# net1 a_6700_5175# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X777 a_10598_4373# a_10391_4373# a_10774_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X778 vssd1 clk a_7838_2767# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X779 a_10313_3677# a_9779_3311# a_10218_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X780 a_7350_4511# a_7182_4765# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X781 net10 a_12743_3829# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X782 a_2414_2223# a_2099_2375# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X783 vssd1 a_16463_3463# _33_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X784 vccd1 a_12312_5639# _22_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X785 a_12454_5814# sr\[4\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X786 a_8038_4982# net11 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X787 a_2217_3311# a_2051_3311# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X788 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X789 a_10774_4765# a_10527_4399# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X790 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X791 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X792 a_3041_4399# a_2051_4399# a_2915_4765# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X793 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X794 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X795 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X796 a_4955_4373# _17_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X797 _13_ a_1959_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X798 a_13569_5241# sr\[6\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X799 a_7810_3423# a_7642_3677# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X800 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X801 net2 a_1867_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X802 net1 a_10055_7119# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X803 vssd1 a_10901_5241# a_10835_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X804 a_12993_4399# sr\[6\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X805 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X806 a_10326_4399# a_10011_4551# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X807 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X808 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X809 a_4981_2223# _13_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X810 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X811 vssd1 a_3111_5652# _11_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X812 a_12312_5639# net1 a_12454_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X813 a_9945_3311# a_9779_3311# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X814 vssd1 _25_ a_6553_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X815 a_12318_2741# a_12150_2767# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X816 a_10945_4399# a_10398_4673# a_10598_4373# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X817 a_12318_2741# a_12150_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X818 a_10472_5175# net3 a_10614_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X819 a_11969_3311# a_11803_3311# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X820 vssd1 a_2019_5175# _30_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X821 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X822 a_15807_3476# _33_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X823 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X824 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X825 a_7566_2223# a_7251_2375# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X826 a_2019_5175# sr\[3\] a_2193_5281# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X827 a_7369_3311# a_7203_3311# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X828 a_10614_4982# sr_dly\[0\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X829 vccd1 a_12575_2767# a_12743_2741# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X830 a_5173_4399# sr\[3\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X831 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X832 vccd1 net10 a_18059_7127# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X833 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X834 vssd1 a_10643_3677# a_10811_3579# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X835 vssd1 a_4036_7093# dq[1] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X836 a_7221_5461# sr\[2\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X837 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X838 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X839 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X840 a_10107_4373# a_10391_4373# a_10326_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X841 vssd1 _01_ a_12877_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X842 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X843 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X844 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X845 vssd1 a_5875_4373# _09_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X846 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X847 vssd1 clknet_0_clk a_7930_3855# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X848 a_12793_3311# a_11803_3311# a_12667_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X849 a_4149_3311# a_3983_3311# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X850 vssd1 clknet_1_0__leaf_clk a_3983_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X851 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X852 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X853 a_9405_5263# _17_ a_9187_5175# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X854 vccd1 sr\[1\] a_6178_4649# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X855 vssd1 a_4043_4551# _28_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X856 a_7838_2767# clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X857 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X858 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X859 a_2490_4765# a_2217_4399# a_2405_4399# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X860 vccd1 clknet_1_1__leaf_clk a_9779_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X861 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X862 a_8193_3311# a_7203_3311# a_8067_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X863 a_7347_2197# a_7631_2197# a_7566_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X864 a_12530_2197# a_12323_2197# a_12706_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X865 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X866 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X867 vccd1 clknet_1_0__leaf_clk a_2051_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X868 a_12410_3423# a_12242_3677# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X869 vccd1 a_2915_4765# a_3083_4667# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X870 vccd1 net7 a_12263_7127# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X871 a_12575_3855# a_11711_3861# a_12318_3829# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X872 a_12679_2223# a_12459_2223# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X873 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X874 vssd1 a_12318_3829# a_12276_4233# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X875 a_12706_2589# a_12459_2223# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X876 a_13599_4982# net1 a_13140_5175# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X877 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X878 a_4973_3311# a_3983_3311# a_4847_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X879 a_12575_2767# a_11877_2773# a_12318_2741# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X880 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X881 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X882 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X883 vccd1 net6 a_7847_7127# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X884 a_14699_5487# net9 a_14336_5639# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X885 vccd1 a_2915_3677# a_3083_3579# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X886 a_12530_2197# a_12330_2497# a_12679_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X887 sr\[6\] a_10811_2491# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X888 vssd1 a_2915_4765# a_3083_4667# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X889 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X890 a_10643_2589# a_9945_2223# a_10386_2335# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X891 a_12741_5461# sr\[4\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X892 vssd1 clknet_1_0__leaf_clk a_4627_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X893 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X894 dq[4] a_12263_7127# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X895 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X896 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X897 a_4590_3423# a_4422_3677# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X898 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X899 vccd1 _17_ _00_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X900 vccd1 a_12743_3829# a_12659_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X901 vccd1 a_15531_4074# _02_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X902 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X903 a_12877_2223# a_12323_2197# a_12530_2197# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X904 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X905 _19_ a_14411_4427# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X906 _32_ a_16895_4193# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X907 a_12877_2223# a_12330_2497# a_12530_2197# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X908 vssd1 a_1867_2767# net2 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X909 a_12065_3855# _03_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X910 a_15807_3476# _33_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X911 a_10643_3677# a_9779_3311# a_10386_3423# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X912 a_6934_5814# sr\[2\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X913 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X914 a_4771_4087# a_5062_3977# a_5013_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X915 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X916 dq[3] a_7847_7127# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X917 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X918 vssd1 clknet_1_1__leaf_clk a_11711_3861# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X919 vssd1 a_11127_5639# _31_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X920 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X921 a_5262_4132# a_5062_3977# a_5411_4221# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X922 a_2099_2375# a_2195_2197# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X923 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X924 sr\[2\] a_5659_2491# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X925 a_9920_5639# net1 a_10062_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X926 a_4675_4087# a_4771_4087# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X927 a_10785_4175# _17_ a_10567_4087# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X928 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X929 vssd1 _20_ a_12073_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X930 a_12659_2767# a_11877_2773# a_12575_2767# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X931 a_7182_4765# a_6909_4399# a_7097_4399# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X932 a_12158_4649# _20_ a_11855_4373# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X933 net10 a_12743_3829# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X934 vccd1 sr\[3\] a_2019_5175# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X935 a_5871_5162# _31_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X936 vssd1 a_5262_4132# a_5191_4233# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X937 a_2479_2197# clknet_1_0__leaf_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X938 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X939 vssd1 a_7221_5461# a_7155_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X940 vccd1 a_8067_3677# a_8235_3579# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X941 vccd1 a_10811_3579# a_10727_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X942 dq[2] a_5692_7093# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X943 vccd1 net2 a_14411_4427# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X944 vccd1 clknet_0_clk a_2673_2741# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X945 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X946 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X947 a_7838_2767# clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X948 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X949 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X950 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X951 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X952 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X953 a_12150_2767# a_11711_2773# a_12065_2767# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X954 a_4981_2223# _13_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X955 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X956 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X957 vssd1 a_6335_3285# _08_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X958 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X959 a_17291_3463# net11 a_17465_3339# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X960 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X961 vccd1 sr\[4\] a_11127_5639# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X962 vccd1 a_7350_4511# a_7277_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X963 a_10218_2589# a_9779_2223# a_10133_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X964 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X965 a_10391_4373# clknet_1_1__leaf_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X966 vccd1 a_6979_4087# _10_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X967 a_12242_3677# a_11969_3311# a_12157_3311# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X968 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X969 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X970 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X971 a_12276_3145# a_11877_2773# a_12150_2767# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X972 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X973 a_7129_5241# sr\[1\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X974 a_2673_2741# clknet_0_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X975 a_7251_2375# a_7347_2197# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X976 a_11877_2773# a_11711_2773# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X977 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X978 _00_ _17_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X979 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X980 a_12459_2223# a_12330_2497# a_12039_2197# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X981 a_5173_4399# _17_ a_4955_4373# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X982 vssd1 a_11943_2375# sr_dly\[0\] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X983 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X984 a_10344_2223# a_9945_2223# a_10218_2589# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X985 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X986 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X987 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X988 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X989 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u l=590000u
X990 vssd1 a_12575_2767# a_12743_2741# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
D1 vssd1 comp sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
X991 a_7631_2197# clknet_1_1__leaf_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X992 vccd1 _29_ a_2235_5487# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X993 a_2915_4765# a_2217_4399# a_2658_4511# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X994 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X995 vssd1 a_10386_2335# a_10344_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X996 a_5055_4073# clknet_1_0__leaf_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=640000u l=150000u
X997 vccd1 a_12410_3423# a_12337_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X998 clknet_1_1__leaf_clk a_7930_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X999 vccd1 _01_ a_12877_2223# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1000 a_2658_4511# a_2490_4765# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X1001 vccd1 a_14336_5639# _21_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X1002 a_14478_5814# sr\[5\] vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1003 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X1004 vccd1 _09_ a_5609_4233# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1005 a_5191_4233# a_5062_3977# a_4771_4087# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1006 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
R1 vssd1 valid sky130_fd_pr__res_generic_po w=480000u l=45000u
X1007 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X1008 a_4217_4427# net2 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1009 a_9405_5263# sr\[4\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1010 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.05e+06u
X1011 a_2195_2197# a_2486_2497# a_2437_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1012 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X1013 vccd1 a_16863_7127# dq[6] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X1014 a_5871_5162# _31_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X1015 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=590000u
X1016 net5 a_3083_3579# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1017 vssd1 a_5015_3579# a_4973_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1018 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1019 a_7987_2223# a_7767_2223# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1020 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1021 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X1022 vccd1 a_9920_5639# _23_ vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X1023 a_13140_5175# net1 a_13282_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1024 a_10133_2223# _02_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1025 a_8014_2589# a_7767_2223# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1026 a_14336_5639# net1 a_14478_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1027 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1028 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1029 a_4517_3677# a_3983_3311# a_4422_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1030 vccd1 a_2479_2197# a_2486_2497# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X1031 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X1032 vccd1 a_1644_7093# dq[0] vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X1033 dq[6] a_16863_7127# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1034 vssd1 a_8325_5241# a_8259_5309# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1035 a_2217_4399# a_2051_4399# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1036 a_2915_4765# a_2051_4399# a_2658_4511# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1037 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=1.97e+06u
X1038 a_4990_4221# a_4675_4087# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1039 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X1040 vssd1 _10_ a_3033_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1041 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.97e+06u
X1042 a_10931_4982# net1 a_10472_5175# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1043 a_7930_3855# clknet_0_clk vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1044 vssd1 clk a_7838_2767# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1045 vccd1 sr\[6\] a_16463_3463# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1046 a_10835_5309# net3 a_10472_5175# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1047 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X1048 a_7197_4175# _17_ a_6979_4087# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1049 a_7930_3855# clknet_0_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1050 a_12454_5487# sr\[4\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1051 vssd1 a_15531_4074# _02_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X1052 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1053 a_4036_7093# net4 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X1054 vssd1 a_2939_5175# _29_ vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1055 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X1056 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X1057 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=590000u
X1058 vccd1 clknet_0_clk a_2673_2741# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1059 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1060 a_7896_5175# net4 a_8038_4982# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1061 a_5491_2589# a_4793_2223# a_5234_2335# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1062 vssd1 a_12667_3677# a_12835_3579# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X1063 vccd1 a_2673_2741# clknet_1_0__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X1064 a_11301_5515# net2 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1065 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X1066 vssd1 a_18059_7127# dq[7] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1067 _17_ a_3707_4951# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1068 vssd1 _15_ a_10945_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1069 a_3167_4233# a_3031_4073# a_2747_4087# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1070 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1071 a_2615_2223# a_2486_2497# a_2195_2197# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1072 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X1073 a_7350_4511# a_7182_4765# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X1074 vssd1 _14_ a_3585_4233# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
D2 vssd1 clk sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
X1075 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1076 a_6842_5309# sr\[1\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1077 a_7063_5309# net5 a_6700_5175# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1078 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1079 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1080 a_3113_5281# net2 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1081 vssd1 a_12743_3829# a_12701_4233# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1082 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1083 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X1084 vccd1 net9 a_16863_7127# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X1085 vssd1 _29_ a_2235_5487# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=520000u
+ l=150000u
X1086 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1087 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1088 a_10785_4175# sr\[5\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1089 a_6638_3561# _25_ a_6335_3285# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1090 a_10283_5487# net7 a_9920_5639# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1091 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X1092 vssd1 _26_ a_6093_4399# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1093 vssd1 a_7930_3855# clknet_1_1__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1094 a_11877_3861# a_11711_3861# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X1095 a_2490_3677# a_2051_3311# a_2405_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1096 a_16911_2986# _18_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X1097 vccd1 comp a_10055_7119# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X1098 a_10901_5241# sr_dly\[0\] vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1099 a_6178_4649# _26_ a_5875_4373# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1100 clknet_1_0__leaf_clk a_2673_2741# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X1101 a_1644_7093# net3 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u
+ l=150000u
X1102 a_2999_3677# a_2217_3311# a_2915_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1103 vccd1 a_10643_3677# a_10811_3579# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1104 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X1105 clknet_1_1__leaf_clk a_7930_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X1106 vssd1 a_4847_3677# a_5015_3579# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X1107 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=590000u
X1108 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1109 a_10527_4399# a_10398_4673# a_10107_4373# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=360000u l=150000u
X1110 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=2.89e+06u
X1111 a_2616_3311# a_2217_3311# a_2490_3677# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1112 a_3033_2223# a_2479_2197# a_2686_2197# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1113 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1114 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=1.05e+06u
X1115 a_7607_4765# a_6743_4399# a_7350_4511# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1116 a_3387_4221# a_3167_4233# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1117 a_3033_2223# a_2486_2497# a_2686_2197# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1118 a_10107_4373# a_10398_4673# a_10349_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1119 vssd1 a_12263_7127# dq[4] vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u
+ l=150000u
X1120 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1121 vccd1 a_7221_5461# a_7251_5814# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1122 vccd1 a_3238_4132# a_3167_4233# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X1123 a_4675_4087# a_4771_4087# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=650000u l=150000u
X1124 vssd1 a_7838_2767# clknet_0_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1125 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1126 clknet_1_0__leaf_clk a_2673_2741# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1127 vssd1 a_2658_3423# a_2616_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1128 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1129 a_7767_2223# a_7638_2497# a_7347_2197# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1130 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1131 vccd1 a_7930_3855# clknet_1_1__leaf_clk vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=1e+06u l=150000u
X1132 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=590000u
X1133 a_11943_2375# a_12039_2197# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1134 vccd1 a_10391_4373# a_10398_4673# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X1135 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1136 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1137 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=590000u
X1138 vccd1 clknet_0_clk a_7930_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1139 vccd1 a_3083_3579# a_2999_3677# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1140 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=4.73e+06u
X1141 net1 a_10055_7119# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X1142 a_5066_2589# a_4627_2223# a_4981_2223# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1143 a_12318_3829# a_12150_3855# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=750000u l=150000u
X1144 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1145 vccd1 a_7775_4667# a_7691_4765# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1146 a_5575_2589# a_4793_2223# a_5491_2589# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1147 clknet_0_clk a_7838_2767# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1148 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1149 a_7642_3677# a_7203_3311# a_7557_3311# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1150 a_12323_2197# clknet_1_1__leaf_clk vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1151 vssd1 a_2673_2741# clknet_1_0__leaf_clk vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=420000u l=150000u
X1152 a_12667_3677# a_11803_3311# a_12410_3423# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1153 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=590000u
X1154 vssd1 vccd1 vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=550000u l=2.89e+06u
X1155 a_12318_3829# a_12150_3855# vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=640000u l=150000u
X1156 a_12065_2767# _00_ vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1157 vccd1 vssd1 vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=870000u
+ l=4.73e+06u
X1158 vccd1 sr\[2\] a_6638_3561# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
X1159 a_5192_2223# a_4793_2223# a_5066_2589# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=360000u l=150000u
X1160 vccd1 _30_ a_1959_3855# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=790000u
+ l=150000u
X1161 last_cycle a_17507_2223# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u
+ w=1e+06u l=150000u
X1162 vssd1 net8 a_14471_7127# vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1163 a_2405_3311# _08_ vssd1 vssd1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u
+ l=150000u
X1164 a_8067_3677# a_7203_3311# a_7810_3423# vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p
+ ps=0u w=420000u l=150000u
X1165 sr\[6\] a_10811_2491# vccd1 vccd1 sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u
+ l=150000u
C0 vccd1 net3 6.31fF
C1 vccd1 sr\[6\] 2.34fF
C2 vccd1 net11 4.56fF
C3 vccd1 sr\[1\] 2.08fF
C4 vccd1 _17_ 5.18fF
C5 vccd1 sr\[5\] 2.81fF
C6 vccd1 net2 7.65fF
C7 vccd1 _01_ 2.12fF
C8 vccd1 sr\[3\] 3.29fF
C9 vccd1 sr\[2\] 2.24fF
C10 vccd1 _12_ 2.07fF
C11 vccd1 _02_ 3.63fF
C12 vccd1 net1 2.40fF
C13 vccd1 net10 2.55fF
C14 clknet_0_clk vccd1 3.04fF
C15 vccd1 net9 2.26fF
C16 vccd1 net8 2.39fF
C17 vccd1 net7 2.64fF
C18 vccd1 clknet_1_1__leaf_clk 3.64fF
C19 vccd1 _15_ 2.22fF
C20 vccd1 net5 3.04fF
C21 vccd1 clknet_1_0__leaf_clk 4.11fF
C22 rst_n vssd1 2.09fF
C23 vccd1 vssd1 447.23fF
C24 _16_ vssd1 3.91fF $ **FLOATING
C25 clknet_0_clk vssd1 3.61fF $ **FLOATING
C26 clknet_1_1__leaf_clk vssd1 2.65fF $ **FLOATING
C27 clknet_1_0__leaf_clk vssd1 3.58fF $ **FLOATING
C28 _00_ vssd1 4.08fF $ **FLOATING
C29 sr\[6\] vssd1 2.05fF $ **FLOATING
C30 net11 vssd1 4.38fF $ **FLOATING
C31 _17_ vssd1 2.56fF $ **FLOATING
C32 sr\[5\] vssd1 5.67fF $ **FLOATING
C33 net2 vssd1 2.31fF $ **FLOATING
C34 net1 vssd1 4.55fF $ **FLOATING
C35 net6 vssd1 2.00fF $ **FLOATING
.ends


XDUT clk comp dq[0] dq[1] dq[2] dq[3] dq[4] dq[5] dq[6] dq[7] last_cycle rst_n valid vlo vhi
+ sarcon_sync_flat


**** end user architecture code
**.ends
.end
